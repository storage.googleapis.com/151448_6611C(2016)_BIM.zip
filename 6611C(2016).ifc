Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-04-12T14:06:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 12 14:06:10 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{3D39E9A9-B654-4FC3-8BF1-30BD6930E001}\ifc * Database version: 5507 * Database creation date: Fri Apr 12 14:06:09 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 12 14:06:10 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 12 14:06:10 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6611C Cover part for washbasin faucet, 3 V, 6611C(2016):6611C Cover part for washbasin faucet, 3 V:323184
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - Projection: 245 mm
Type - Electrical Engineering(Type) - Operating Voltage: 3 V
Type - Electrical(Type) - Battery: AA 1.5 V Lithium x 2; Electronic Parts: Autofocus sensor;Solenoid valve;Control unit;Signal lights;Low battery indication
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6611C(2016); ConvergoRefNr: 0087-1905-0050-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 08/04/2019
Type - Green Building Properties(Type) - Customs Code: 84819000; EAN Number: 6414150080265; EMC Directive: 2014/30/EU; Protection Class: IP 55
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/6611C; Catalog Drawing URL: http://static.oras.com/catdrw/6611C; Class: Touchless, trim Kit, battery-operated; Dimension Drawing URL: http://static.oras.com/dimdrw/6611C; FDV Document URL: http://www.oras.com/datasheet/6611C/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6611C; Group: Washbasin faucets; Long Marketing: Touchless wall-mounted washbasin faucet for cold or pre-mixed water. Battery-operated 3 V (AA 1.5 V Lithium x 2). Spout lenght 245mm. Body part Oras Bluebox (No. 2081 or 2080) has to be ordered separately. Parameters can be changed with a magnetic key, included in the package.; Manufacturer: Oras; Market: POL;RUS;LTU;LVA;UKR; Model: 6611C Cover part for washbasin faucet, 3 V; Name_en: 6611C Cover part for washbasin faucet, 3 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 370 x 192 x 90; Package Weight: 1.8588 kg; Product Code: 6611C; Product Datasheet: http://www.oras.com/datasheet/6611C/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6611C; Product URL: http://static.oras.com/6611C; Type Name: 6611C Cover part for washbasin faucet, 3 V
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Aerator: Pressure controlled aerator;CASCADE; Afterflow Period: 3; Automatic Flush: off (off/6/12/18/24/30/36/48/60/72 h); Automatic Flush Period: 30 s (30/60/90/120/180/240/300/360/480/600 s); CWFU: 0; Flow Rate At 300kPa With Flow Controller: 0.00282517 m3/s; Installation and Maintenance: http://static.oras.com/manual/6611C; Installation Type: Wall mounted for concealed unit; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 60; Recognition Range: Optimally preset; Spare Parts: http://static.oras.com/sp/6611C; Temperature: Preset water temperature
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Public & semi-public; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6611C(2016); Features: Touchless, trim Kit, battery-operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6611C; Name: 6611C Cover part for washbasin faucet, 3 V; ReplacementCost: n/a; Shape: Sculptured; Size: 170x170x260 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6611C; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6611C Cover part for washbasin faucet, 3 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.1173 m2; Volume: 0.007514 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6611C(2016): 6611C Cover part for washbasin faucet, 3 V; Family and Type: 6611C(2016): 6611C Cover part for washbasin faucet, 3 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6611C(2016): 6611C Cover part for washbasin faucet, 3 V; Type Id: 6611C(2016): 6611C Cover part for washbasin faucet, 3 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
